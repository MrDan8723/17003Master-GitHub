# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Library\CMSIS\MDK;.\Library\STM32F10x_StdPeriph_Driver\inc;.\User;.\Library\CMSIS\CM3;.\Library\CMSIS;.\Firmware;.\Firmware\MNTC_CanBusCtrl
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c Scope_SendData.c SysWork.c 17003UI.c Calibration.c
  group Firmware
    ./Firmware/: USART_Configuration.c DW_Agreement.c Barcode_V0.1.c Delay.c EXTI_Configuration.c TIM.c
    ./Firmware/MNTC_CanBusCtrl/: MNTC_CanConfig.c MNTC_CanProtocol.c
  group CMSIS
    ./Library/CMSIS/CM3/: core_cm3.c system_stm32f10x.c
  group Libraries
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_can.c
  group Startup
    ./Library/CMSIS/MDK/: startup_stm32f10x_cl.s
